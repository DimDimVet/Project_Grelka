# Keil uVision project Grelka_F407.uvprojx, settings and files
target Grelka_F407 (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Grelka_F407
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c HEHAL.c RCC.c fonts.c delay.c
  group inc
    ./inc/: app.h HEHAL.h ADC.h GPIO.h PWR.h RCC.h I2C.h ssd1306.h fonts.h delay.h
  group drivers
    ./drivers/: ADC.c GPIO.c PWR.c I2C.c ssd1306.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
